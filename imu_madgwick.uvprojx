# Keil uVision project imu_madgwick.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imu_madgwick
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\Source\app;.\Source\uart;.\Source\imu_ism20948;.\Source\Fusion
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group App
    ./Source/app/: common.h led_unit.c led_unit.h main.c system_clock_init.c system_clock_init.h filter_proces.c filter_proces.h
  group Uart
    ./Source/uart/: crc16.c crc16.h uart_driver.c uart_driver.h uart_protocol_types.h
  group IMU_ISM20948
    ./Source/imu_ism20948/: imu_data_types.h imu_ism20948.c imu_ism20948.h spi_driver.c spi_driver.h
  group Fusion
    ./Source/Fusion/: Fusion.h FusionAhrs.c FusionAhrs.h FusionBias.c FusionBias.h FusionCompass.c FusionCompass.h FusionConvention.h FusionMath.h FusionModel.h FusionRemap.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.5
